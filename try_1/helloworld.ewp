# IAR project helloworld.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Components/utils; Components/common; Components/basicrf; Components/targets/interface; Components/assembly; Components/common/cc8051; Components/targets/srf05_soc; Components/radios/cc2530
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group Application
    ./: hello.c
  group Basic RF
    components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal/common
    Components/common/cc8051/: hal_cc8051.h
    Components/common/: hal_defs.h
    components/common/: hal_int.c hal_lcd_srf05.c hal_types.h
  group hal/interface
    Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h hal_rf.h hal_rf_security.h hal_rf_util.h hal_timer_32k.h
    components/targets/interface/: hal_uart.h
  group hal/rf
    components/radios/cc2530/: adc.c clock.c hal_mcu.c hal_rf.c hal_rf_security.c hal_rf_util.c hal_timer_32k.c
    Components/radios/cc2530/: adc.h clock.h
  group hal/srf05_soc
    components/targets/srf05_soc/: hal_assert.c hal_board.c hal_button.c hal_digio.c hal_joystick.c hal_led.c
    Components/targets/srf05_soc/: hal_board.h
  group Utilities
    components/utils/: util.c util_buffer.c util_buffer.h util_lcd.c util_lcd.h util_menu.h
    Components/utils/: util.h
